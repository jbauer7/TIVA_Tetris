# Keil uVision project ece353_base_project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c fonts.c led_lut.h adc.h boardUtil.h gpioPort.h interrupts.h timers.h adc.c boardUtil.c gpioPort.c interrupts.c timers.c pc_buffer.c uart.c pc_buffer.h uart.h input.c input.h watchdog.h watchdog.c eeprom.c i2c.c io_expander.c eeprom.h i2c.h io_expander.h lcd.c lcd.h rf.c led.c game_logic.c render.c game_constants.h game_logic.h game_pieces.h led.h main_game.h render.h spi.c wireless.c wireless.h
    ../include/: eadogs102w.h spi.h fonts.h
  group lib
    ../lib/: ece353_project.lib
  group ::Device
    RTE/Device/TM4C123GH6PM/: startup_TM4C123.s system_TM4C123.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
